# 多串口配置：支持 ttyS0, ttyAMA0, ttyAMA1
SERIAL_CONSOLES:raspberrypi3-64 = "115200;ttyS0 115200;ttyAMA0 115200;ttyAMA1"